## arch/arm64/configs/vendor/surya-perf_defconfig
```kconfig
CONFIG_MSM_ADRENO_BOOST=y
CONFIG_ADRENO_BOOST=y
CONFIG_DRM_MSM_SDE_60_120_SMOOTH=y
```
